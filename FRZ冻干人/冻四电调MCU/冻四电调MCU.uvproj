# Keil uVision project 冻四电调MCU.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C58 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(24000000)
  output: 冻四电调MCU +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: a_comfunc.c a_ll1func.c a_strfunc.c a_timerfunc.c bmp180.c Delay_12M.c EEPROM.c main.c mainioport.c mpu9250iica.c UNIQ_ID.c stc12_adc.c bmp280iica.c

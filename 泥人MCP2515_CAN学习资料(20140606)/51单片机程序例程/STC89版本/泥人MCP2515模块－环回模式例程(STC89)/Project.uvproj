# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\BSP\Delay;.\BSP\UART;.\BSP\MCP2515
  group USER
    ./: main.c
    ./BSP/MCP2515/: MCP2515.c
